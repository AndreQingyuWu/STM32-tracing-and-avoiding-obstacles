# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: main +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\motor;..\SYSTEM\keysacn;..\SYSTEM\IRSEARCH;..\SYSTEM\IRAvoid
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/DriveLayer/Buzzer/: buzzer.c
    ../SYSTEM/DriveLayer/Led/: led.c
    ../SYSTEM/DriveLayer/Key/: key.c
    ../SYSTEM/AppLayer/Init/: init.c
    ../SYSTEM/AppLayer/ModeSelect/: model_select.c
    ../SYSTEM/DriveLayer/Motion/: motion.c
    ../SYSTEM/DriveLayer/Track/: track.c
    ../SYSTEM/Common/: delay.c sys.c timer.c usart.c
    ../SYSTEM/LogicLayer/SingleTrack/: single_track.c
    ../SYSTEM/LogicLayer/DoubleTrack/: double_track.c
    ../SYSTEM/DriveLayer/Steer/: steer.c
    ../SYSTEM/DriveLayer/UltrasonicAvoid/: ultrasonic_avoid.c
    ../SYSTEM/LogicLayer/RunMaze/: run_maze.c
